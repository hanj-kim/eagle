# Repository hanj-kim/eagle (continued)

## EAGLE design hanjunkim/PMS/PMS alpha_v0.2.brd

Parts:
C31, C32: 2.2uF; 2012
C33: 4.7uF; 2012
C34, C35, C36, C37: 0.1uF; 2012
C38, C39, C40, C41: 1uF; 2012
R17, R19: 510; 2012
R18, R20: 10K; 2012
R21: 4.7K; 2012
SW1: SPST(6.5PITCH); 6.5PITCH
U7: STM32F415/417; LQFP100

Connections:
!NRST: R21.P$1, SW1.P$1, U7.P$14 (NRST)
BOOT4: R19.P$2, R20.P$1, U7.P$37 (PB2(BOOT1))
BOOT5: R17.P$2, R18.P$1, U7.P$94 (BOOT0)
CAN_RX: U7.P$70 (PA11); also elsewhere on the board
CAN_TX: U7.P$71 (PA12); also elsewhere on the board
DGND: C31.P$2, C32.P$2, C33.P$1, C34.P$1, C35.P$1, C36.P$1, C37.P$1, C38.P$1, C39.P$1, C40.P$1, C41.P$1, R17.P$1, R19.P$1, SW1.P$2, U7.P$10 (GND), U7.P$20 (GNDA), U7.P$27 (GND), U7.P$74 (GND), U7.P$99 (GND); also elsewhere on the board
GPS_RX_UART_TX: U7.P$68 (PA9); also elsewhere on the board
GPS_TX_UART_RX: U7.P$69 (PA10); also elsewhere on the board
IMU_SCL: U7.P$95 (PB8(I2C1_SCL)); also elsewhere on the board
IMU_SDA: U7.P$96 (PB9(I2C1_SDA)); also elsewhere on the board
LED_B: U7.P$23 (PA0(WKUP/UART4_TX)); also elsewhere on the board
LED_G: U7.P$24 (PA1(UART4_RX)); also elsewhere on the board
LED_R: U7.P$25 (PA2(UART2_TX)); also elsewhere on the board
LED_STAT1: U7.P$93 (PB7); also elsewhere on the board
LED_STAT2: U7.P$92 (PB6(CAN2_TX)); also elsewhere on the board
LED_STAT3: U7.P$91 (PB5(CAN2_RX)); also elsewhere on the board
LED_STAT4: U7.P$88 (PD7); also elsewhere on the board
LED_STAT5: U7.P$87 (PD6); also elsewhere on the board
LED_STAT6: U7.P$86 (PD5); also elsewhere on the board
LED_STAT7: U7.P$85 (PD4); also elsewhere on the board
LED_STAT8: U7.P$84 (PD3); also elsewhere on the board
LED_STAT9: U7.P$83 (PD2); also elsewhere on the board
LED_STAT10: U7.P$82 (PD1); also elsewhere on the board
LED_STAT11: U7.P$81 (PD0); also elsewhere on the board
LED_STAT12: U7.P$80 (PC12(SPI3_MOSI)); also elsewhere on the board
LED_STAT13: U7.P$79 (PC11(SPI3_MISO)); also elsewhere on the board
LED_STAT14: U7.P$78 (PC10(SPI3_SCK)); also elsewhere on the board
LED_STAT15: U7.P$62 (PD15); also elsewhere on the board
LED_STAT16: U7.P$61 (PD14); also elsewhere on the board
LED_STAT17: U7.P$60 (PD13); also elsewhere on the board
LED_STAT18: U7.P$59 ((USART3_RTS)PD12); also elsewhere on the board
LED_STAT19: U7.P$58 ((USART3_CTS)PD11); also elsewhere on the board
LED_STAT20: U7.P$57 ((USART3_CK)PD10); also elsewhere on the board
LED_STAT21: U7.P$56 ((USART3_RX)PD9); also elsewhere on the board
LED_STAT22: U7.P$55 ((USART3_TX)PD8); also elsewhere on the board
LED_STAT23: U7.P$54 (PB15(SPI2_MOSI)); also elsewhere on the board
LED_STAT24: U7.P$53 (PB14(SPI2_MISO)); also elsewhere on the board
LED_STAT25: U7.P$52 (PB13(SPI2_SCK)); also elsewhere on the board
LED_STAT26: U7.P$51 (PB12(SPI2_CS)); also elsewhere on the board
LED_STAT27: U7.P$48 (PB11(I2C2_SDA)); also elsewhere on the board
LED_STAT28: U7.P$47 (PB10(I2C2_SCL)); also elsewhere on the board
LED_STAT29: U7.P$46 (PE15); also elsewhere on the board
LED_STAT30: U7.P$45 (PE14); also elsewhere on the board
OSC_IN: U7.P$12 ((OSC_IN)PH0)
OSC_OUT: U7.P$13 ((OSC_OUT)PH1)
PA3: U7.P$26 (PA3(UART2_RX))
PA4: U7.P$29 (PA4(SPI1/3_CS))
PA5: U7.P$30 (PA5(SPI1_SCK))
PA6: U7.P$31 (PA6(SPI1_MISO))
PA7: U7.P$32 (PA7(SPI1_MOSI))
PA8: U7.P$67 (PA8)
PA15: U7.P$77 (PA15(JTDI))
PB0: U7.P$35 (PB0)
PB1: U7.P$36 (PB1)
PB3: U7.P$89 (PB3(JTDO/TRACESWO))
PB4: U7.P$90 (PB4(NJRST))
PC0: U7.P$15 (PC0)
PC1: U7.P$16 (PC1(ETH_MDC))
PC2: U7.P$17 (PC2(SPI2_MISO))
PC3: U7.P$18 (PC3(SPI2_MOSI))
PC4: U7.P$33 (PC4)
PC5: U7.P$34 (PC5)
PC8: U7.P$65 (PC8)
PC9: U7.P$66 (PC9)
PC13: U7.P$7 (PC13(EVENTOUT))
PC14: U7.P$8 (PC14(OSC32_IN))
PC15: U7.P$9 (PC15(OSC32_OUT))
PE0: U7.P$97 (PE0)
PE1: U7.P$98 (PE1)
PE2: U7.P$1 (PE2)
PE3: U7.P$2 (PE3)
PE4: U7.P$3 (PE4)
PE5: U7.P$4 (PE5)
PE6: U7.P$5 (PE6)
PE7: U7.P$38 (PE7)
PE8: U7.P$39 (PE8)
PE9: U7.P$40 (PE9)
PE10: U7.P$41 (PE10)
PE11: U7.P$42 (PE11)
PE12: U7.P$43 (PE12)
PE13: U7.P$44 (PE13)
SWCLK: U7.P$76 (PA14(SWCLK/JTCK)); also elsewhere on the board
SWDIO: U7.P$72 (PA13(SWDIO/JTMS)); also elsewhere on the board
USB_RX_UART_TX: U7.P$63 (PC6); also elsewhere on the board
USB_TX_UART_RX: U7.P$64 (PC7); also elsewhere on the board
VCAP5: C32.P$1, U7.P$73 (VCAP_2)
VCAP6: C31.P$1, U7.P$49 (VCAP_1)
VCC_3.3V: C33.P$2, C34.P$2, C35.P$2, C36.P$2, C37.P$2, C38.P$2, C39.P$2, C40.P$2, C41.P$2, R18.P$2, R20.P$2, R21.P$2, U7.P$6 (VBAT), U7.P$11 (VCC), U7.P$19 (VCC), U7.P$21 (VREF+), U7.P$22 (VCCA), U7.P$28 (VCC), U7.P$50 (VCC), U7.P$75 (VCC), U7.P$100 (VCC); also elsewhere on the board

Parts:
J1: 4PIN_2.54; 4PIN
R1, R2, R5: 330; 2012
R24, R25: 4.7K; 2012
U1: MPU-9250; GY-9250
U2: GPS6MV2; PAD_2.5MM
U10: RGB_COM_K; RGB_4PIN_2.5MM

Connections:
DGND: J1.P$2 (2), U1.P$2 (GND), U2.P$4 (GND), U10.P$4 (K); also elsewhere on the board
GPS_RX_UART_TX: U2.P$2 (RX); also elsewhere on the board
GPS_TX_UART_RX: U2.P$3 (TX); also elsewhere on the board
IMU_SCL: R24.P$1, U1.P$3 (SCL/SCK); also elsewhere on the board
IMU_SDA: R25.P$1, U1.P$4 (SDA/SDI); also elsewhere on the board
LED_B: R5.P$1; also elsewhere on the board
LED_G: R2.P$1; also elsewhere on the board
LED_R: R1.P$1; also elsewhere on the board
unnamed: R1.P$2, U10.P$1 (A)
unnamed: R2.P$2, U10.P$2 (A)
unnamed: R5.P$2, U10.P$3 (A)
SWCLK: J1.P$3 (3); also elsewhere on the board
SWDIO: J1.P$4 (4); also elsewhere on the board
VCC_3.3V: J1.P$1 (1), R24.P$2, R25.P$2, U1.P$1 (VCC), U2.P$1 (VCC); also elsewhere on the board

Notes on the sheet:
IMU
SWD
GPS
RGB LED

Parts:
C1: 100nF; 2012
C13: 22uF; 2012
D8: SBR10E45P5; POWERDI5
D40: LED_CHIP_2012; 2012
R6: 120; 2012
R23: 470K; 2012
R57: 5.1K; 2012
U3: IFX1050GVIO; PG-DSO-8
U5: CP2102-USB; CP2102-6PIN
U9: LTC4412ES6; TSOT-23(3X3)
U11: 24V_TO_12V; 24V_12V_10A
U12: SI4435FDY; SO-8
U13: STR2P3LLH6; SOT-23-3

Connections:
12V: C13.P$2, D8.K, R23.P$2, U12.1 (S), U12.2 (S), U12.3 (S), U13.3 (D); also elsewhere on the board
24V: U11.24V+, U11.24V+$1 (24V+); also elsewhere on the board
CANH: R6.P$2, U3.P7 (CANH)
CANL: R6.P$1, U3.P6 (CANL)
CAN_MODE: U3.P8 (INH)
CAN_RX: U3.P4 (RXD); also elsewhere on the board
CAN_TX: U3.P1 (TXD); also elsewhere on the board
DGND: C1.P$1, C13.P$1, R57.P$1, U3.P2 (GND), U5.P$5 (GND), U9.P$2 (GND), U9.P$3 (CTL), U11.12V-; also elsewhere on the board
EXT.GND: U11.24V-, U11.24V-$1 (24V-)
unnamed: U9.P$5 (GATE), U12.4 (G)
unnamed: R23.P$1, U9.P$4 (STAT), U13.1 (G)
unnamed: D40.K, R57.P$2
unnamed: D40.A, U13.2 (S)
USB_RX_UART_TX: U5.P$3 (RXD); also elsewhere on the board
USB_TX_UART_RX: U5.P$4 (TXD); also elsewhere on the board
VBAT_12V: U9.P$1 (VIN), U12.5 (D), U12.6 (D), U12.7 (D), U12.8 (D); also elsewhere on the board
VCC_3.3V: C1.P$2, U3.P5 (V3.3); also elsewhere on the board
VCC_5V: U3.P3 (VCC); also elsewhere on the board
V_SMPS_12V: D8.A$1 (A), D8.A$2 (A), U9.P$6 (SENSE), U11.12V+

Notes on the sheet:
UART to USB
CAN
PowerPath
24V to 12V SMPS

Parts:
C4, C10: 22nF; 2012
C5, C11: 22uF; 2012
C6, C12: 10uF; 2012
D2, D4: NSR20F30; DSN2(1608)
L2, L4: 4.7uH; 2012
R3: 9.53K; 2012
R4, R8: 49.9K; 2012
R7: 16.3K; 2012
U4, U6: ACT4088US-T; SOT-23-6

Connections:
12V: C6.P$2, C12.P$2, U4.2 (IN), U6.2 (IN); also elsewhere on the board
DGND: C5.P$1, C6.P$1, C11.P$1, C12.P$1, D2.A, D4.A, R3.P$1, R7.P$1, U4.5 (GND), U6.5 (GND); also elsewhere on the board
unnamed: C4.P$1, U4.6 (BST)
unnamed: C4.P$2, D2.K, L2.P$1, U4.1 (SW)
unnamed: R3.P$2, R4.P$1, U4.4 (FB)
unnamed: C10.P$1, U6.6 (BST)
unnamed: C10.P$2, D4.K, L4.P$1, U6.1 (SW)
unnamed: R7.P$2, R8.P$1, U6.4 (FB)
VCC_3.3V: C11.P$2, L4.P$2, R8.P$2; also elsewhere on the board
VCC_5V: C5.P$2, L2.P$2, R4.P$2; also elsewhere on the board

Notes on the sheet:
12V to 5V regulator
12V to 3.3V regulator
SWD

Parts:
C2: 10uF; 2012
C3: 4.7uF; 2012
C7: 22uF; 2012
C8: 1uF; 2012
C9: 100uF; F55_SIZE(SMD)
D1, D39: LED_CHIP_2012; 2012
D3, D5, D6: NSR20F30; DSN2(1608)
D7: BZX84C6V2L; SOT-23
L1: 22uH; 4040SIZE
R9: 499K; 2012
R10: 63.4K; 2012
R11, R56: 5.1K; 2012
R12: 309K; 2012
R13: 100K; 2012
R14: 910; 2012
R15: 174K; 2012
R16: 0.1; 6432
R22: NCP18XH103; 1608
U8: LTC3652HVIMSE; MSOP-12

Connections:
24V: D1.A, D5.A, D39.A; also elsewhere on the board
!CHRG!: R56.P$1, U8.P$4 (!CHRG!)
!FAULT!: R11.P$1, U8.P$5 (!FAULT!)
DGND: C2.P$1, C3.P$1, C7.P$1, C9.GND, D3.A, R10.P$1, R13.P$1, R22.P$1, U8.P$13 (GND); also elsewhere on the board
unnamed: R9.P$1, R10.P$2, U8.P$2 (V_IN_REG)
unnamed: C2.P$2, D5.K, R9.P$2, U8.P$1 (V_IN), U8.P$3 (!SHDN!)
unnamed: D1.K, R11.P$2
unnamed: C3.P$2, U8.P$6 (TIMER)
unnamed: D39.K, R56.P$2
unnamed: R12.P$1, R13.P$2, R15.P$1
unnamed: R14.P$2, U8.P$8 (NTC)
unnamed: R15.P$2, U8.P$7 (V_FB)
unnamed: C8.P$2, D3.K, L1.P$2, U8.P$12 (SW)
unnamed: C8.P$1, D6.K, U8.P$11 (BOOST)
unnamed: L1.P$1, R16.P$1, U8.P$10 (SENSE)
unnamed: R14.P$1, R22.P$2
unnamed: D6.A, D7.P$1 (A)
VBAT_12V: C7.P$2, C9.VCC, D7.P$3 (K), R12.P$2, R16.P$2, U8.P$9 (BAT); also elsewhere on the board

Notes on the sheet:
Lead Acid Battery Charger

Parts:
D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38: LED_5MM_DIP; DIP_5MM
R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55: 1K; 2012

Connections:
LED_STAT1: D9.K; also elsewhere on the board
LED_STAT2: D10.K; also elsewhere on the board
LED_STAT3: D11.K; also elsewhere on the board
LED_STAT4: D12.K; also elsewhere on the board
LED_STAT5: D13.K; also elsewhere on the board
LED_STAT6: D14.K; also elsewhere on the board
LED_STAT7: D15.K; also elsewhere on the board
LED_STAT8: D16.K; also elsewhere on the board
LED_STAT9: D17.K; also elsewhere on the board
LED_STAT10: D18.K; also elsewhere on the board
LED_STAT11: D19.K; also elsewhere on the board
LED_STAT12: D20.K; also elsewhere on the board
LED_STAT13: D21.K; also elsewhere on the board
LED_STAT14: D22.K; also elsewhere on the board
LED_STAT15: D23.K; also elsewhere on the board
LED_STAT16: D24.K; also elsewhere on the board
LED_STAT17: D25.K; also elsewhere on the board
LED_STAT18: D26.K; also elsewhere on the board
LED_STAT19: D27.K; also elsewhere on the board
LED_STAT20: D28.K; also elsewhere on the board
LED_STAT21: D29.K; also elsewhere on the board
LED_STAT22: D30.K; also elsewhere on the board
LED_STAT23: D31.K; also elsewhere on the board
LED_STAT24: D32.K; also elsewhere on the board
LED_STAT25: D33.K; also elsewhere on the board
LED_STAT26: D34.K; also elsewhere on the board
LED_STAT27: D35.K; also elsewhere on the board
LED_STAT28: D36.K; also elsewhere on the board
LED_STAT29: D37.K; also elsewhere on the board
LED_STAT30: D38.K; also elsewhere on the board
unnamed: D9.A, R26.P$2
unnamed: D10.A, R27.P$2
unnamed: D15.A, R32.P$2
unnamed: D11.A, R28.P$2
unnamed: D12.A, R29.P$2
unnamed: D13.A, R30.P$2
unnamed: D14.A, R31.P$2
unnamed: D16.A, R33.P$2
unnamed: D17.A, R34.P$2
unnamed: D18.A, R35.P$2
unnamed: D19.A, R36.P$2
unnamed: D20.A, R37.P$2
unnamed: D21.A, R38.P$2
unnamed: D22.A, R39.P$2
unnamed: D23.A, R40.P$2
unnamed: D24.A, R41.P$2
unnamed: D25.A, R42.P$2
unnamed: D26.A, R43.P$2
unnamed: D27.A, R44.P$2
unnamed: D28.A, R45.P$2
unnamed: D29.A, R46.P$2
unnamed: D30.A, R47.P$2
unnamed: D31.A, R48.P$2
unnamed: D32.A, R49.P$2
unnamed: D33.A, R50.P$2
unnamed: D34.A, R51.P$2
unnamed: D35.A, R52.P$2
unnamed: D36.A, R53.P$2
unnamed: D37.A, R54.P$2
unnamed: D38.A, R55.P$2
VCC_3.3V: R26.P$1, R27.P$1, R28.P$1, R29.P$1, R30.P$1, R31.P$1, R32.P$1, R33.P$1, R34.P$1, R35.P$1, R36.P$1, R37.P$1, R38.P$1, R39.P$1, R40.P$1, R41.P$1, R42.P$1, R43.P$1, R44.P$1, R45.P$1, R46.P$1, R47.P$1, R48.P$1, R49.P$1, R50.P$1, R51.P$1, R52.P$1, R53.P$1, R54.P$1, R55.P$1; also elsewhere on the board

Notes on the sheet:
MCU
- 초기 버전에서 M4 버전으로 진행하되, 이는 변경될 수 있음
- IMU는 납땜을 최소화 하기 위해 기성품을 Alpha 버전에서 사용
- 24V까지 통신 가능한 CAN 포트 추가
- 통신용 USB to UART 포트 추가
- 상태지시용 LED 추가
- 12V 납축충전회로 추가

Board: 4 copper layers, 140.0 x 140.0 mm, 139 parts (0 on the bottom side), 116 nets.

# Repository hanj-kim/eagle

## EAGLE design projects/MODI/BatteryModule/base_module_e1_0.1.brd

Parts:
C1: 0.1uF; 1005
C2: 1uF; 1005
C3, C4: 22uF; 1608
J1, J2: MODI_CONNECTOR_BOTTOM; 3P
J3: AXK720447G; SOCKET_20P
L1: 33uH; 2518
P1: MODI_BAT_BASE; BAT_BASE
R1, R3, R8: 10K; 1005
R2, R4: 1K; 1005
R5, R6: 4.99K; 1005
R7: 45K; 1005
TP4, TP7, TP8, TP9, TP10, TP11, TP12: TEST_POINT_1.2MM_PAD; 1.2MM_PAD
TP13, TP14, TP15: TEST_POINT; 0.7MM_HOLE
U1: STM8S003FXU6; UFQFPN20
U2: SY8089; SOT-23-5
U3: PMXBXXXXPE; DFN1010D-3

Connections:
3.3V: C1.P$2, C4.P$2, J3.P1 (1), L1.P$2, R7.P$2, TP14.1, U1.6 (VCC)
!NRST!: TP9.P1, U1.1 (!NRST!)
BAT_ADC: J3.P16 (16), U1.16 ((TIM2_CH3)PD2)
CHARGE_ADC: J3.P14 (14), TP7.P1, U1.17 ((TIM2_CH2)PD3)
DEVICE_RX_STM8_TX: J3.P10 (10), U1.19 ((UART1_TX)PD5)
DEVICE_TX_STM8_RX: J3.P8 (8), U1.20 ((UART1_RX)PD6)
DGND: C1.P$1, C2.P$1, C3.P$1, C4.P$1, J3.P18 (18), J3.P20 (20), R1.P$1, R3.P$1, R6.P$1, R8.P$1, TP15.1, U1.4 (GND), U2.2 (GND), U3.P1 (G)
DIR1: R1.P$2, R2.P$1, U1.7 (PA3(TIM2_CH3))
DIR2: R3.P$2, R4.P$1, U1.8 (PB5(I2C_SDA))
EN: J3.P12 (12), TP4.P1, U1.18 ((TIM2_CH1)PD4)
LBO: J3.P5 (5), U1.12 ((SPI_SCK)PC5)
LED_B: J3.P9 (9), TP12.P1, U1.10 ((TIM1_CH3)PC3)
LED_G: J3.P11 (11), TP11.P1, U1.13 ((SPI_MOSI)PC6)
LED_R: J3.P13 (13), TP10.P1, U1.14 ((SPI_MISO)PC7)
unnamed: J2.P1 (1), J2.P3 (3), R4.P$2
unnamed: J1.P1 (1), J1.P3 (3), R2.P$2
unnamed: R7.P$1, R8.P$2, U2.5 (FB)
unnamed: L1.P$1, U2.3 (LX)
PWR: J3.P2 (2), J3.P4 (4), R5.P$2, U3.P3 (D)
PWR_ADC: R5.P$1, R6.P$2, TP8.P1, U1.11 ((TIM1_CH4)PC4)
PWR_OUT: J1.P2 (2), J2.P2 (2), U3.P2 (S)
SYS_SWIM: J3.P15 (15), TP13.1, U1.15 ((SWIM)PD1)
VBAT: C3.P$2, J3.P3 (3), U2.1 (EN), U2.4 (IN)
VCAP: C2.P$2, U1.5 (VCAP)
VER: J3.P7 (7), U1.9 (PB4(I2C_SCL))

Notes on the sheet:
Hanjun Kim (Tuna)
PWR ADC
Bypass Capacitor
Test Point
Buck Controller
B2B Conenctor
MCU
LUX CONNECTOR 3PIN

Board: 2 copper layers, 14.5 x 17.8 mm, 30 parts (16 on the bottom side), 25 nets.

## EAGLE design design blocks/hanjkim/CAN module.brd

Parts:
C1: 100nF; 2012
R1: RESISTOR_CHIP_2012; 2012
U1: IFX1050GVIO; PG-DSO-8

Connections:
CANH: U1.P7 (CANH)
CANL: U1.P6 (CANL)
DGND: C1.P$1, R1.P$1, U1.P2 (GND)
unnamed: R1.P$2, U1.P8 (INH)
RXD: U1.P4 (RXD)
TXD: U1.P1 (TXD)
VCC: U1.P3 (VCC)
VREF: C1.P$2, U1.P5 (VREF)

Board: 2 copper layers, 3 parts (0 on the bottom side), 3 nets.

## EAGLE design hanjunkim/PMS/PMS alpha_v0.1.brd

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11: CAPACITOR_CHIP2012; 2012
R1, R2, R3, R4, R5: RESISTOR_CHIP_2012; 2012
U3: STM32F415/417; LQFP100

Connections:
!NRST: R5.P$1, U3.P$14 (NRST)
AGND: C10.P$1, U3.P$20 (GNDA)
BOOT0: R1.P$2, R2.P$1, U3.P$94 (BOOT0)
BOOT1: R3.P$2, R4.P$1, U3.P$37 (PB2(BOOT1))
DGND: C1.P$2, C2.P$2, C3.P$1, C4.P$1, C5.P$1, C6.P$1, C7.P$1, C8.P$1, C9.P$1, C11.P$1, R1.P$1, R3.P$1, U3.P$10 (GND), U3.P$27 (GND), U3.P$74 (GND), U3.P$99 (GND); also elsewhere on the board
GPS_RX_MCU_TX: U3.P$25 (PA2(UART2_TX)); also elsewhere on the board
GPS_TX_MCU_RX: U3.P$26 (PA3(UART2_RX)); also elsewhere on the board
IMU-AD0: U3.P$47 (PB10(I2C2_SCL)); also elsewhere on the board
IMU-FSYNC: U3.P$52 (PB13(SPI2_SCK)); also elsewhere on the board
IMU-INT: U3.P$48 (PB11(I2C2_SDA)); also elsewhere on the board
IMU-NCS: U3.P$51 (PB12(SPI2_CS)); also elsewhere on the board
IMU-SCL: U3.P$95 (PB8(I2C1_SCL)); also elsewhere on the board
IMU-SDA: U3.P$96 (PB9(I2C1_SDA)); also elsewhere on the board
LED_B: U3.P$71 (PA12); also elsewhere on the board
LED_G: U3.P$70 (PA11); also elsewhere on the board
LED_R: U3.P$69 (PA10); also elsewhere on the board
OSC_IN: U3.P$12 ((OSC_IN)PH0)
OSC_OUT: U3.P$13 ((OSC_OUT)PH1)
PA0: U3.P$23 (PA0(WKUP/UART4_TX))
PA1: U3.P$24 (PA1(UART4_RX))
PA4: U3.P$29 (PA4(SPI1/3_CS))
PA5: U3.P$30 (PA5(SPI1_SCK))
PA6: U3.P$31 (PA6(SPI1_MISO))
PA7: U3.P$32 (PA7(SPI1_MOSI))
PA8: U3.P$67 (PA8)
PA9: U3.P$68 (PA9)
PA15: U3.P$77 (PA15(JTDI))
PB0: U3.P$35 (PB0)
PB1: U3.P$36 (PB1)
PB3: U3.P$89 (PB3(JTDO/TRACESWO))
PB4: U3.P$90 (PB4(NJRST))
PB5: U3.P$91 (PB5(CAN2_RX))
PB6: U3.P$92 (PB6(CAN2_TX))
PB7: U3.P$93 (PB7)
PB14: U3.P$53 (PB14(SPI2_MISO))
PB15: U3.P$54 (PB15(SPI2_MOSI))
PC0: U3.P$15 (PC0)
PC1: U3.P$16 (PC1(ETH_MDC))
PC2: U3.P$17 (PC2(SPI2_MISO))
PC3: U3.P$18 (PC3(SPI2_MOSI))
PC4: U3.P$33 (PC4)
PC5: U3.P$34 (PC5)
PC6: U3.P$63 (PC6)
PC7: U3.P$64 (PC7)
PC8: U3.P$65 (PC8)
PC9: U3.P$66 (PC9)
PC10: U3.P$78 (PC10(SPI3_SCK))
PC11: U3.P$79 (PC11(SPI3_MISO))
PC12: U3.P$80 (PC12(SPI3_MOSI))
PC13: U3.P$7 (PC13(EVENTOUT))
PC14: U3.P$8 (PC14(OSC32_IN))
PC15: U3.P$9 (PC15(OSC32_OUT))
PD0: U3.P$81 (PD0)
PD1: U3.P$82 (PD1)
PD2: U3.P$83 (PD2)
PD3: U3.P$84 (PD3)
PD4: U3.P$85 (PD4)
PD5: U3.P$86 (PD5)
PD6: U3.P$87 (PD6)
PD7: U3.P$88 (PD7)
PD8: U3.P$55 ((USART3_TX)PD8)
PD9: U3.P$56 ((USART3_RX)PD9)
PD10: U3.P$57 ((USART3_CK)PD10)
PD11: U3.P$58 ((USART3_CTS)PD11)
PD12: U3.P$59 ((USART3_RTS)PD12)
PD13: U3.P$60 (PD13)
PD14: U3.P$61 (PD14)
PD15: U3.P$62 (PD15)
PE0: U3.P$97 (PE0)
PE1: U3.P$98 (PE1)
PE2: U3.P$1 (PE2)
PE3: U3.P$2 (PE3)
PE4: U3.P$3 (PE4)
PE5: U3.P$4 (PE5)
PE6: U3.P$5 (PE6)
PE7: U3.P$38 (PE7)
PE8: U3.P$39 (PE8)
PE9: U3.P$40 (PE9)
PE10: U3.P$41 (PE10)
PE11: U3.P$42 (PE11)
PE12: U3.P$43 (PE12)
PE13: U3.P$44 (PE13)
PE14: U3.P$45 (PE14)
PE15: U3.P$46 (PE15)
SWDCLK: U3.P$76 (PA14(SWCLK/JTCK))
SWDIO: U3.P$72 (PA13(SWDIO/JTMS))
VBAT: C11.P$2, U3.P$6 (VBAT)
VCAP1: C1.P$1, U3.P$49 (VCAP_1)
VCAP2: C2.P$1, U3.P$73 (VCAP_2)
VCCA: C10.P$2, U3.P$22 (VCCA)
VCC_3.3V: C3.P$2, C4.P$2, C5.P$2, C6.P$2, C7.P$2, C8.P$2, R2.P$2, R4.P$2, R5.P$2, U3.P$11 (VCC), U3.P$19 (VCC), U3.P$28 (VCC), U3.P$50 (VCC), U3.P$75 (VCC), U3.P$100 (VCC); also elsewhere on the board
VREF: C9.P$2, U3.P$21 (VREF+)

Parts:
U1: MPU-9250; GY-9250
U2: GPS6MV2; PAD_2.5MM
U$1: RGB_COM_K; RGB_4PIN_2.5MM

Connections:
DGND: U1.P$2 (GND), U2.P$4 (GND), U$1.P$4 (K); also elsewhere on the board
GPS_RX_MCU_TX: U2.P$2 (RX); also elsewhere on the board
GPS_TX_MCU_RX: U2.P$3 (TX); also elsewhere on the board
IMU-AD0: U1.P$7 (AD0/SD0); also elsewhere on the board
IMU-FSYNC: U1.P$10 (FSYNC); also elsewhere on the board
IMU-INT: U1.P$8 (INT); also elsewhere on the board
IMU-NCS: U1.P$9 (NCS); also elsewhere on the board
IMU-SCL: U1.P$3 (SCL/SCK); also elsewhere on the board
IMU-SDA: U1.P$4 (SDA/SDI); also elsewhere on the board
LED_B: U$1.P$3 (A); also elsewhere on the board
LED_G: U$1.P$2 (A); also elsewhere on the board
LED_R: U$1.P$1 (A); also elsewhere on the board
VCC_3.3V: U1.P$1 (VCC), U2.P$1 (VCC); also elsewhere on the board

Notes on the sheet:
IMU
BUZZER
GPS
RGB LED

Parts:
C12, C13, C14, C16, C17, C18: 22nF; 2012
C15, C19: 10uF; 2012
D1, D2: BAT60JFILM; SOD323
L1, L2: 3.3uH; 2012
R6, R9: 10k; 2012
R7, R10: 49.9K; 2012
R8: 9.53K; 2012
R11: 16.2K; 2012
U4, U5: AP5100; SOT-26

Connections:
BST: C12.P$1, U4.P1 (BST)
BST1: C16.P$1, U5.P1 (BST)
DGND: C14.P$1, C15.P$1, C18.P$1, C19.P$1, D1.A, D2.A, R8.P$1, R11.P$1, U4.P2 (GND), U5.P2 (GND); also elsewhere on the board
EN: R6.P$1, U4.P4 (EN)
EN1: R9.P$1, U5.P4 (EN)
FB: C13.P$1, R7.P$1, R8.P$2, U4.P3 (FB)
FB1: C17.P$1, R10.P$1, R11.P$2, U5.P3 (FB)
SW: C12.P$2, D1.K, L1.P$1, U4.P6 (SW)
SW1: C16.P$2, D2.K, L2.P$1, U5.P6 (SW)
VIN: C15.P$2, C19.P$2, R6.P$2, R9.P$2, U4.P5 (IN), U5.P5 (IN)
VOUT: C13.P$2, C14.P$2, C17.P$2, C18.P$2, L1.P$2, L2.P$2, R7.P$2, R10.P$2

Notes on the sheet:
12V to 5V regulator
12V to 3.3V regulator

Notes on the sheet:
MCU
- 초기 버전에서 M4 버전으로 진행하되, 이는 변경될 수 있음
- IMU는 납땜을 최소화 하기 위해 기성품을 Alpha 버전에서 사용
- 24V까지 통신 가능한 CAN 포트 추가
- 통신용 USB to UART 포트 추가

Board: 2 copper layers, 40 parts (0 on the bottom side), 32 nets, no tracks yet.

## EAGLE design DesignBlock/DesignBlock/AP5100.brd

Parts:
C1, C2, C3: 22nF; 2012
C4: 10uF; 2012
D1: BAT60JFILM; SOD323
L1: INDUCTOR2012; 2012
R1, R2, R3: 10k; 2012
U1: AP5100; SOT-26

Connections:
BST: C1.P$1, U1.P1 (BST)
DGND: C3.P$1, C4.P$1, D1.A, R3.P$1, U1.P2 (GND)
EN: R1.P$1, U1.P4 (EN)
FB: C2.P$1, R2.P$1, R3.P$2, U1.P3 (FB)
SW: C1.P$2, D1.K, L1.P$1, U1.P6 (SW)
VIN: C4.P$2, R1.P$2, U1.P5 (IN)
VOUT: C2.P$2, C3.P$2, L1.P$2, R2.P$2

Board: 2 copper layers, 10 parts (0 on the bottom side), 7 nets.
